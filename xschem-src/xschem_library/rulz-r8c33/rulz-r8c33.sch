** sch_path: xschem-src/xschem_library/rulz-r8c33/rulz-r8c33.sch
* Copyright (C) 1998-2026 Stefan Frederik Schippers
* This program is free software; you can redistribute it and/or modify
* it under the terms of the GNU General Public License as published by
* the Free Software Foundation; either version 2 of the License, or
* (at your option) any later version.
* This program is distributed in the hope that it will be useful,
* but WITHOUT ANY WARRANTY; without even the implied warranty of
* MERCHANTABILITY or FITNESS FOR A PARTICULAR PURPOSE.  See the
* GNU General Public License for more details.
* You should have received a copy of the GNU General Public License
* along with this program; if not, write to the Free Software
* Copyright (C) 2010 DJ Delorie (dj delorie com)
* Public License, either version 2 or (at your choice)
**.subckt rulz-r8c33
* CONN1 ?1 RAW_5V ?1 USBDM ?1 USBDP ?1 net24 ?1 GND ?1 net22 ?1 net23   usb-minib
*connector(8,1) ?1 +5V ?1 GND ?1 net4 ?1 net5 ?1 net6 ?1 net7 ?1 net8 ?1 net9 ?1 net10 ?1 net11 ?1
*+ P3.3 ?1 P3.4 ?1 P3.5 ?1 P3.7
* JP1 ?1 +5V ?1 +5V
U2 +5V MODE RESET XOUT GND XIN +5V P3.7 P3.5 P3.4 P3.3 net21 net20 net19 net25 net26 net4 net5 net6
+ net7 net8 net9 net10 net11 net12 net13 net14 net15 RXD TXD RTS CTS r8c-33c
U1 USBDM USBDP net27 net28 net29 GND 3V3OUT GND USB_5V USB_5V URX UTX MODE net30 PWREN RESET CTS
+ net31 net32 net33 RTS RXD TXD GND ft232rl
* noconn #net24
* noconn #net22
LED8 +5V net34 LED
R5 net34 GND 3.3k m=1
L1 RAW_5V USB_5V 600@100 m=1
C2 USB_5V GND 4.7uF m=
C1 RAW_5V GND 10nF m=1
Q1 USB_5V net1 +5V DMP2035U m=1
C3 net1 GND 100nF m=1
R1 net1 PWREN 1k m=1
LED1 +5V net2 LED
R2 net2 URX 1k m=1
LED2 +5V net3 LED
R3 net3 UTX 1k m=1
C5 +5V GND 100nF m=1
* noconn #net30
R4 +5V P3.5 3.3k m=1
R6 +5V P3.7 3.3k m=1
C6 +5V GND 100nF m=1
C4 3V3OUT GND 100nF m=1
* noconn #net29
* noconn #net28
* noconn #net27
* noconn #net31
* noconn #net32
* noconn #net33
R7 net12 net35 1k m=1
LED3 net35 GND LED
R8 net13 net36 1k m=1
LED4 net36 GND LED
R9 net14 net37 1k m=1
LED5 net37 GND LED
R10 net15 net38 1k m=1
LED6 net38 GND LED
R15 XOUT XIN 1MEG m=1
LED7 net18 net16 net17 GND GND GND XXX
R11 net19 net18 1k m=1
R12 net20 net16 1k m=1
R13 net21 net17 1k m=1
* noconn #net25
* noconn #net26
X1 XOUT GND XIN crystal-2
* noconn #net23
**.ends
.GLOBAL GND
.GLOBAL +5V
.end
